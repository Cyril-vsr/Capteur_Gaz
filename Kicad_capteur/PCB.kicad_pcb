# Repository Cyril-vsr/Capteur_Gaz

File README.md:

# ISS 2024/2025: Gas Sensor AIME

## Introduction

This project involves designing and implementing a smart gas sensor. Starting with its fabrication at the AIME laboratory, the project extended to integrating the sensor with an Arduino UNO and LoRa module for wireless communication.

The objective was to create a system capable of detecting gas, processing the data, and transmitting it to a remote dashboard via LoRaWAN. This project helped us gain hands-on experience in electronics, programming, and networking.

## Gas Sensor

The gas sensor was fabricated during a training period at AIME. It uses [material, e.g., nanoparticles of WO3], which allows for high sensitivity to specific gases like [e.g., ethanol, ammonia].

The sensor includes:

- **Sensitive layer**: Nanoparticles deposited on interdigitated aluminum combs.
  
- **Heating element**: A polysilicon resistor to adjust operating temperature.
  
- **Calibration zone**: An area without nanoparticles for baseline measurements.

| **Pin Number** | **Description**                       |
|----------------|---------------------------------------|
| 2, 4           | Sensitive layer (with nanoparticles) |
| 3, 6           | Heating element                      |
| 5, 10          | Temperature sensor                   |
| 7, 9           | Calibration layer                    |
| 1, 8           | Not used                             |

## Wiring

To create a functional system, we wired the following components:

- **Arduino UNO**: Central microcontroller for the system.
- **LoRa Module (RN2483)**: For wireless communication.
- **Gas Sensor**: To detect gas concentrations.

 The connections were as follows:

- **Gas sensor**: Connected to the analog pin A0 on the Arduino.
- **LoRa module**: TX and RX connected to pins 10 and 11 on the Arduino.
- **Power**: Arduino powered via USB, LoRa module powered through the 3.3V pin.

<div align="center">

</div>

## Arduino Code

The Arduino code consists of two parts:

1) **Initialization**: Retrieve and configure the LoRa module with its EUI for registration in the LoRaWAN network (via ChirpStack).
2) **Data Transmission**: Read gas sensor values, process the data, and send it via LoRa.

**Code Highlights**

The setup() function initializes the LoRa module and the gas sensor.
The loop() function reads the sensor data, encodes it, and transmits it using the sendBytes() function.

**Configuration Parameters:**

- AppEUI: Configured for LoRaWAN registration.
- AppKey: Security key for LoRaWAN.
- Sensor Pin: Pin A0 for the gas sensor.
- LoRa TX/RX: Pins 10 and 11 for communication.

## Kicad
Below is a view of the routed PCB on KiCad.

## Node-Red Overview

The Node-RED flow for this project is designed to receive, process, and display data from a LoRa sensor. The flow involves:

1) **Data Reception**: An MQTT node listens for incoming sensor data, typically from a LoRaWAN network like ChirpStack.
2) **Data Extraction**: A function node decodes the received Base64-encoded data and extracts the gas level value.
3) **Data Processing**: Another function node analyzes the gas level and triggers an alert if the value exceeds a set threshold (e.g., 200).
4) **Visualization**: A chart node displays the real-time gas levels in the Node-RED dashboard.

Flow Highlights:
- MQTT Node: Configured to receive sensor data from a LoRa network.
- Function Nodes: Process and filter the incoming data (e.g., extract, decode, and analyze gas levels).
- Chart Node: Displays the data in real-time on a graphical interface.

<div align="center">
  
</div>

Key Parameters:
- MQTT broker configuration: Connects to the LoRa network.
- Threshold value: Set to 200 for triggering the alert.
- Dashboard: Accessible via http://127.0.0.1:1880/ui.
<div align="center">
  
</div>

## MIT App Inventor

The MIT App Inventor app is designed to connect to the Arduino, allowing users to control the system and view sensor data in real-time.

Features:

1) **Connect to Arduino**: The app connects to the Arduino via Bluetooth when the user presses a connect button.
2) **Control LED**: Users can turn the LED on or off using buttons in the app.
3) **Gas Level Monitoring**: The app continuously receives the current gas level from the sensor and displays it.
4) **Real-time Updates**: Gas level data is updated in real-time on the app interface.

<div align="center">

</div>

Key Components:
- Connect Button: Establishes communication with the Arduino.
- LED Control Buttons: Turns the LED on and off.
- Label: Displays the current gas level.
- Notifier: Alerts the user if the gas level exceeds a predefined threshold.
  
This app provides simple, real-time interaction with the Arduino system, enabling both control and monitoring of environmental conditions.

## KiCad design Kicad_capteur/PCB.kicad_pcb

Parts:
C1, C2, C3: 100n; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J3: Analog; PinSocket_1x06_P2.54mm_Vertical
J4: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
J5: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
LTC1: DIP-8_W7.62mm_LongPads
Q1: Q_NMOS_GSD; TO-220-3_Vertical
R1, R2: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R6: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4, R5: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7, R8: 0; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
S1: TO-5-10_Window
SW1: SW_SPDT; SW_Push_2P2T_Toggle_CK_PVA2xxH2xxxxxxV2
U1: MCP41100; DIP-8_W7.62mm

Connections:
12V: Q1.2 (S), R5.2, S1.3 (HeatherResistor)
+3.3V: J1.4, J5.6
+5V: C3.1, J1.5, LTC1.7 (V+), S1.4 (GasSensorLeft), S1.9 (GasSensorRight), U1.8 (VDD)
+12V: J1.8, R5.1
/4: J4.4
/8: J2.10
/*3: J4.5
/*6: J4.2
/*9: J2.9
/*10: J2.8
/IOREF: J1.2
/RX/0: J4.8
/TX/1: J4.7
/~RESET: J1.3
ADC: C2.1, J3.1, R3.2
GND: C1.2, C2.2, C3.2, J1.6, J1.7, J2.4, J5.8, LTC1.4 (v-), Q1.3 (D), R1.1, S1.1 (TempSensor), S1.5 (GND), S1.8 (HeatherResistor), S1.10 (GND), U1.1 (~CS), U1.4 (VSS), U1.6 (PW0), U1.7 (PB0)
GasSensor1: R8.1, SW1.1 (A)
GasSensor2: S1.2 (GasSensorLeft), SW1.3 (C)
MOSI: J4.1, U1.3 (SI)
unnamed: C1.1, LTC1.3 (+input), R1.2, R4.1
unnamed: C4.1, LTC1.6 (vOut), R2.2, R3.1
unnamed: Q1.1 (G), R6.2
unnamed: R7.2, S1.6 (TempSensor)
unnamed: R8.2, S1.7 (GasSensorRight)
unnamed: R4.2, SW1.2 (B)
RVar: C4.2, LTC1.2 (-input), R2.1, U1.5 (PA0)
SCK: J4.3, U1.2 (SCK)
TempSensor: J3.2, R7.1
gas_choic_ctrl: J4.6, R6.1
rst: J2.5, J5.3
rx: J2.7, J5.2
tx: J2.6, J5.1

Notes on the sheet:
Capteur de gaz
Circuit amplificateur avec LTC1050
Capteur LoRa
Résistance variable avec potentiomètre digital MCP41100
Arduino UNO
Gaz type switch

Board: 2 copper layers, 68.6 x 53.3 mm, 26 parts (0 on the bottom side), 22 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm

## Commit log

2024-12-02 test du module lora
2024-12-02 capteur de gaz plus Led
2024-12-02 LED,OLED,CAPTEUR_HUMIDITY
2024-12-03 LORA COMMUNICATION
2024-12-18 Add files via upload
    Kicad
2024-12-18 Node-Red Done
2024-12-18 Node-Red README.md
2024-12-18 Code cleaning
2025-01-13 lt spice
2025-01-13 Add LT Spice
2025-01-20 Datasheet Finish
2025-01-24 Microcontroller and Datasheet Done
2025-01-24 Project Finish
